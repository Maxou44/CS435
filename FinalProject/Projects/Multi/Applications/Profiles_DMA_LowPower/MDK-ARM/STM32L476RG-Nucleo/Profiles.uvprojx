# Keil uVision project Profiles.uvprojx, settings and files
target STM32L476RG_NUCLEO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DMA_LP_profiles +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER,__DMA_LP__
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\LibProfPeriph\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1;..\..\..\..\..\..\Middlewares\ST\TimerServer\inc;..\..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc;..\..\..\..\..\..\Middlewares\ST\LowPowerManager\Inc;..\..\..\..\..\..\STM32xx_HAL_APP_Drivers\inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\STM32L4xx_HAL_BlueNRG_Drivers\inc;..\..\STM32xx_HAL_APP_Drivers\inc;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/HAL_APP_Drivers
    ../../STM32xx_HAL_APP_Drivers/src/: stm32xx_hal_app_rtc.c
  group Application/User
    ../../Src/: anc_profile_application.c ans_profile_application.c bluenrg_interface.c bps_profile_application.c cube_hal_l4.c fml_profile_application.c fmt_profile_application.c gs_profile_application.c hid_profile_application.c hrm_profile_application.c htm_profile_application.c low_power_conf_l4.c main.c pac_profile_application.c pm_profile_application.c pr_profile_application.c profile_application.c stm32xx_it.c tc_profile_application.c ts_profile_application.c stm32l4xx_hal_msp.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble_dma_lp.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c
  group Middlewares/LPM
    ../../../../../../Middlewares/ST/LowPowerManager/Src/: stm32xx_lpm.c
  group Middlewares/STM32_BlueNRG/PeripheralProfiles
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/alert_notification_client/: alertNotification_Client.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/alert_notification_server/: alertNotification_Server.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/ble_profile/: profile.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/blood_pressure_sensor/: blood_pressure_sensor.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/Find_Me_Locator/: findme_locator.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/Find_Me_Target/: findme_target.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/glucose_sensor/: glucose_racp.c glucose_sensor.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/Health_Thermometer/: health_thermometer.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/heart_rate/: heart_rate.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/hid_device/: hid_device.c hid_device_sm_services.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/Phone_Alert_Client/: phoneAlert_Client.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/proximity_monitor/: proximity_monitor.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/proximity_reporter/: proximity_reporter.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/time_client/: time_client.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Src/time_server/: time_server.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfPeriph/Utils/: timer.c
  group Middlewares/STM32_BlueNRG/HAL_Drivers
    ../../../../../../Middlewares/ST/STM32_BlueNRG/STM32L4xx_HAL_BlueNRG_Drivers/src/: stm32l4xx_hal_bluenrg_gpio.c stm32l4xx_hal_bluenrg_syscfg.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci_dma_lp.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c ble_list.c osal.c
  group Middlewares/TimerServer
    ../../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
