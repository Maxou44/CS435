# IAR project ProfilesCentral.ewp, settings and files
configuration L053R8 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L053xx; USE_STM32L0XX_NUCLEO; USE_HAL_DRIVER; SET_L2CAP_CONN_UPD_REQ_COMMAND; SET_TX_POWER_COMMAND
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\LibProfCentr\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1; ..\..\..\..\..\..\Middlewares\ST\TimerServer\inc; ..\..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PrCentr_PROFNAME_L053R8.bin
  ILINK.IlinkOutputFile: Profiles_Central.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../../Src/: anc_central_application.c ans_central_application.c bluenrg_interface.c bp_central_application.c cube_hal_l0.c fml_central_application.c fmt_central_application.c gc_central_application.c hid_central_application.c hr_central_application.c ht_central_application.c main.c pas_central_application.c pm_central_application.c pr_central_application.c stm32l0xx_hal_msp.c stm32xx_it.c tc_central_application.c ts_central_application.c uart_support.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32L053R8_NUCLEO
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/ANC
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/alert_notification_client/: alert_notification_client.c alert_notification_client_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/ANS
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/alert_notification_server/: alert_notification_server.c alert_notification_server_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/BLE_Profile
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/ble_profile/: master_basic_profile.c master_basic_profile_sm.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/BPC
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/blood_pressure_collector/: blood_pressure_collector.c blood_pressure_collector_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/FML
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/find_me_locator/: find_me_locator.c find_me_locator_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/FMT
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/find_me_target/: find_me_target.c find_me_target_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/GC
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/glucose_collector/: glucose_collector.c glucose_collector_CB.c glucose_collector_racp_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/HID
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/hid_host/: hid_host.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/HRC
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/heart_rate_collector/: heart_rate_collector.c heart_rate_collector_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/HTC
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/health_thermometer_collector/: health_thermometer_collector.c health_thermometer_collector_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/PAS
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/phone_alert_status_server/: phone_alert_status_server.c phone_alert_status_server_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/PM
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/proximity_monitor/: proximity_monitor.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/PR
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/proximity_reporter/: proximity_reporter.c proximity_reporter_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/TC
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/time_client/: time_client.c time_client_CB.c
  group Middlewares/STM32_BlueNRG/CentralProfiles/TS
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/time_server/: time_server.c time_server_CB.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Utils/: timer.c
  group Middlewares/TimerServer
    ../../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
