# Keil uVision project ProfCentr.uvprojx, settings and files
target ProfCentr_L476RG_NUCLEO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SensorDemoProject +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER
  c include: ..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\LibProfCentr\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1;..\..\..\..\..\..\Middlewares\ST\TimerServer\inc;..\..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../../Src/: anc_central_application.c ans_central_application.c bluenrg_interface.c bp_central_application.c cube_hal_l4.c fml_central_application.c fmt_central_application.c gc_central_application.c hid_central_application.c hr_central_application.c ht_central_application.c main.c pas_central_application.c pm_central_application.c pr_central_application.c stm32xx_it.c tc_central_application.c ts_central_application.c uart_support.c stm32l4xx_hal_msp.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/STM32_BlueNRG/CentralProfiles
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/alert_notification_client/: alert_notification_client.c alert_notification_client_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/alert_notification_server/: alert_notification_server.c alert_notification_server_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/ble_profile/: master_basic_profile.c master_basic_profile_sm.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/blood_pressure_collector/: blood_pressure_collector.c blood_pressure_collector_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/find_me_locator/: find_me_locator.c find_me_locator_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/find_me_target/: find_me_target.c find_me_target_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/glucose_collector/: glucose_collector.c glucose_collector_CB.c glucose_collector_racp_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/health_thermometer_collector/: health_thermometer_collector.c health_thermometer_collector_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/heart_rate_collector/: heart_rate_collector.c heart_rate_collector_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/hid_host/: hid_host.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/phone_alert_status_server/: phone_alert_status_server.c phone_alert_status_server_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/proximity_monitor/: proximity_monitor.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/proximity_reporter/: proximity_reporter.c proximity_reporter_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/time_client/: time_client.c time_client_CB.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Src/time_server/: time_server.c time_server_CB.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c ble_list.c osal.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/LibProfCentr/Utils/: timer.c
  group Middlewares/TimerServer
    ../../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
